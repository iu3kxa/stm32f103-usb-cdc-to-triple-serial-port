# Keil uVision project main.uvproj, settings and files
target main (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: startup_stm32f103xb.s core_cm3.c hw_config.c main.c misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_it.c stm32f10x_rcc.c stm32f10x_usart.c system_stm32f10x.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_sil.c
  group includes
    ./: core_cm3.h hw_config.h misc.h otgd_fs_cal.h otgd_fs_dev.h otgd_fs_int.h otgd_fs_pcd.h stm32f10x_conf.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_it.h stm32f10x_rcc.h stm32f10x_usart.h system_stm32f10x.h type.h usb_conf.h usb_core.h usb_def.h usb_desc.h usb_init.h usb_int.h usb_istr.h usb_lib.h usb_mem.h usb_prop.h usb_pwr.h usb_regs.h usb_sil.h usb_type.h
